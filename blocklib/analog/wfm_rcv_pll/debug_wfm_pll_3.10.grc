options:
  parameters:
    author: josh
    generate_options: no_gui
    id: debug_wfm_pll_310
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: (int)(demod_rate/48000)
  states: {}
- name: audio_filter_coeffs
  id: variable
  parameters:
    value: firdes.low_pass(1, demod_rate, 15000, 1500, window.WIN_HAMMING, 6.76)
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: demod_rate / audio_decim
  states: {}
- name: deemph_tau
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: demod_rate
  id: variable
  parameters:
    value: (int)(samp_rate/rf_decim)
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: pilot_carrier_filter_coeffs
  id: variable
  parameters:
    value: firdes.complex_band_pass( 1.0, demod_rate, 18980, 19020, 1500, window.WIN_HAMMING, 6.76)
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_delay
  id: variable
  parameters:
    value: (len( pilot_carrier_filter_coeffs) - 1) // 2 + (len(stereo_carrier_filter_coeffs) - 1) // 2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: stereo_carrier_filter_coeffs
  id: variable
  parameters:
    value: firdes.band_pass( -2.0, demod_rate, 37600, 38400, 400, window.WIN_HAMMING, 6.76)
  states: {}
- name: analog_left_fm_deemph
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_rate
    tau: '75e-6'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2 * pmath.pi * 18800 / demod_rate
    min_freq: 2 * pmath.pi * 19200 / demod_rate
    w: '0.001'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: demod_rate / (2 * pmath.pi * deviation)
  states: {}
- name: analog_right_fm_deemph
  id: analog_fm_deemph
  parameters:
    samp_rate: audio_rate
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: demod_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: samp_delay
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/pll_in.fc32
    type: complex
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '10000'
    type: complex
  states: {state: disabled}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: '10000'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: stereo_carrier_filter_coeffs
    type: fff
  states: {}
- name: fft_filter_xxx_1
  id: fft_filter_xxx
  parameters:
    decim: audio_decim
    taps: audio_filter_coeffs
    type: fff
  states: {}
- name: fft_filter_xxx_1_0
  id: fft_filter_xxx
  parameters:
    decim: audio_decim
    taps: audio_filter_coeffs
    type: fff
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '90000'
    decim: rf_decim
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: '20000'
    win: window.WIN_HAMMING
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: pilot_carrier_filter_coeffs
    type: fcc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio.fft import window
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import math as pmath
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import matplotlib.pyplot as plt
      import numpy as np

      plt.plot(np.real(self.snk.data()))
      plt.plot(np.imag(self.snk.data()))
      plt.figure()
      plt.plot(np.real(self.snk2.data()))
      plt.plot(np.imag(self.snk2.data()))

      plt.show()
    section: main_after_stop
  states: {state: disabled}
- name: snk
  id: blocks_vector_sink_x
  parameters:
    type: complex
  states: {state: disabled}
- name: snk2
  id: blocks_vector_sink_x
  parameters:
    type: float
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: '90500000'
    gain: '40'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_left_fm_deemph, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_left_fm_deemph, '0', blocks_null_sink_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_head_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '1']
- [analog_quadrature_demod_cf_0, '0', blocks_delay_0, '0']
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0, '0']
- [analog_right_fm_deemph, '0', blocks_null_sink_0_0, '0']
- [analog_sig_source_x_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_add_xx_0, '0', analog_right_fm_deemph, '0']
- [blocks_add_xx_1, '0', analog_left_fm_deemph, '0']
- [blocks_complex_to_imag_0, '0', blocks_head_0_0, '0']
- [blocks_complex_to_imag_0, '0', fft_filter_xxx_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_1, '1']
- [blocks_delay_0, '0', fft_filter_xxx_1_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', snk, '0']
- [blocks_head_0_0, '0', snk2, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_xx_1, '0', fft_filter_xxx_1, '0']
- [fft_filter_xxx_0, '0', blocks_multiply_xx_1, '0']
- [fft_filter_xxx_1, '0', blocks_add_xx_0, '1']
- [fft_filter_xxx_1, '0', blocks_add_xx_1, '1']
- [fft_filter_xxx_1_0, '0', blocks_add_xx_0, '0']
- [fft_filter_xxx_1_0, '0', blocks_add_xx_1, '0']
- [filter_fft_low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [fir_filter_xxx_0, '0', analog_pll_refout_cc_0, '0']
- [soapy_rtlsdr_source_0, '0', filter_fft_low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-245-g09930fdc
