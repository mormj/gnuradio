options:
  parameters:
    author: josh
    generate_options: no_gui
    id: debug_wfm_pll
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: (int)(demod_rate/48000)
  states: {}
- name: deemph_tau
  id: variable
  parameters:
    value: '75e-6'
  states: {}
- name: demod_rate
  id: variable
  parameters:
    value: (int)(samp_rate/rf_decim)
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: stereo_carrier_filter_coeffs
  id: variable
  parameters:
    value: firdes.band_pass( -2.0, demod_rate, 37600, 38400, 400, window.HAMMING, 6.76)
  states: {}
- name: blocks_vector_source_0
  id: blocks_vector_source
  parameters:
    T: float
    data: list(range(10000))
    impl: cpu
    repeat: 'True'
    showports: 'False'
    tags: '[]'
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio.kernel.filter import firdes
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio.kernel.fft import window
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import matplotlib.pyplot as plt
      import numpy as np

      plt.plot(np.real(fg.snk.data()))
      plt.plot(np.imag(fg.snk.data()))
      plt.figure()
      plt.plot(fg.stereo_carrier_filter_coeffs)
      plt.show()
    section: main_after_stop
  states: {}
- name: snk
  id: blocks_vector_sink
  parameters:
    T: float
    impl: cpu
    reserve_items: '1024'
    showports: 'False'
    vlen: '1'
  states: {}
- name: stereo_carrier_bpf
  id: filter_fft_filter
  parameters:
    decimation: '1'
    impl: cpu
    nthreads: '0'
    samp_delay: '0'
    showports: 'False'
    taps: stereo_carrier_filter_coeffs
    type_inst: fff
  states: {}
- name: streamops_head_0
  id: streamops_head
  parameters:
    impl: cpu
    itemsize: '0'
    nitems: '10000'
    showports: 'False'
  states: {}

connections:
- [blocks_vector_source_0, '0', stereo_carrier_bpf, '0']
- [stereo_carrier_bpf, '0', streamops_head_0, '0']
- [streamops_head_0, '0', snk, '0']

metadata:
  file_format: 1
